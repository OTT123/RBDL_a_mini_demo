Commit message: add class

File: urdf/ur5_robot.urdf (robot description, URDF)
Before this commit: robot ur5, 11 links, 10 joints
Links:
- removed link base
- removed link world
Joints:
- removed joint base_link-base_fixed_joint
- removed joint world_joint
